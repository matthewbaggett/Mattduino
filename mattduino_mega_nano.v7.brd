File: mattduino_mega_nano.v7.brd (EAGLE design)
At the start: 94 x 25.4 mm, 29 parts, among them IC1 ATMEGA2560-16AU

Commit message: missing stuff
Parts:
- renumbered J4 to ICSP
